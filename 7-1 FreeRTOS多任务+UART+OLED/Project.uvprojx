# Keil uVision project Project.uvprojx, settings and files
target FREERTOS_UART_OLED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,HSE_VALUE=8000000
  c misc: --c99
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x08000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\User\STM32F103C8.sct
  link misc: --strict
  group Start
    ./Start/: core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_usart.c stm32f10x_usart.h
  group User
    ./User/: FreeRTOSConfig.h main.c STM32F103C8.sct stm32f10x_conf.h stm32f10x_it.c
  group System
    ./System/: App.c App.h Delay.c Delay.h DemoCommand.c DemoCommand.h
  group Hardware
    ./Hardware/: LED.c LED.h OLED.c OLED.h OLED_Config.h OLED_Font.h OLED_SPI.c OLED_SPI.h Serial.c Serial.h
  group FreeRTOS
    ./FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ./FreeRTOS/: list.c queue.c tasks.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
