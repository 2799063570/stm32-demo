# Keil uVision project Project.uvprojx, settings and files
target AUBO_CARTESIAN_REMOTE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,HSE_VALUE=8000000
  c misc: --c99
  c include: .\Start;.\Library;.\User;.\System;.\Hardware
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\User\STM32F103C8.sct
  link misc: --strict
  group Start
    ./Start/: core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_usart.c stm32f10x_usart.h
  group User
    ./User/: JogConfig.h main.c STM32F103C8.sct stm32f10x_conf.h stm32f10x_it.c
  group System
    ./System/: Delay.c Delay.h JogRemote.c JogRemote.h JogView.c JogView.h RemoteJogProtocol.c RemoteJogProtocol.h RemoteProtocol.c RemoteProtocol.h
  group Hardware
    ./Hardware/: JogKeys.c JogKeys.h Joystick.c Joystick.h OLED.c OLED.h OLED_Config.h OLED_Font.h OLED_SPI.c OLED_SPI.h Serial.c Serial.h
